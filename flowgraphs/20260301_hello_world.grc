options:
  parameters:
    author: Michael Allemann
    generate_options: qt_gui
    id: fm_viewer
    output_language: python
    title: Cyberdeck SDR Hello World
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/michael/gnuradio-data/captures/20260301_hello_world.dat
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '103300000'
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'False'
    samplerate: '2000000'
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '103300000'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
